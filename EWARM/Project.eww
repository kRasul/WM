<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IAR_WM_v0.10.ewp</path>
  </project>
  <batchBuild />
</workspace>
